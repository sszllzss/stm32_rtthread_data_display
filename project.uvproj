# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, STM32F103xE, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\finsh;.;rt-thread\include;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;libraries\STM32F1xx_HAL\CMSIS\Include;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: nrf24l01_init.c main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c backtrace.c
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: pipe.c ringbuffer.c waitqueue.c ringblk_buf.c workqueue.c dataqueue.c completion.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c cmd.c
  group Kernel
    rt-thread/src/: idle.c components.c thread.c mem.c timer.c object.c scheduler.c ipc.c clock.c kservice.c irq.c mempool.c device.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
